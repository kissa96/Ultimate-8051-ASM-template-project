# Keil uVision project Template_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C552 NXP
  cpu: IRAM(0-0xFF) CLOCK(30000000)
  output: Template_project +hex
  c flags: Optimize=9 SizeSpeed=1
  group Headers
    ./: CONFIG.inc gyak552_uv2.inc MACROS.inc ALIASES.inc EXTERNAL_BIT_VARIABLES.inc EXTERNAL_BITADDRESSABLE_VARIABLES.inc EXTERNAL_CONSTANTS.inc EXTERNAL_DATA.inc EXTERNAL_IDATA.inc EXTERNAL_STACK_REFERENCE.inc EXTERNAL_SUBROUTINES.inc EXTERNAL_XDATA.inc EXTERNALS.inc
  group Config_errors
    ./: Config_errors.a51
  group Data_Space
    ./: BIT_VARIABLES.a51 STACK.a51 CONSTANTS.a51 DATA_VARIABLES.a51 IDATA_VARIABLES.a51 BITADDRESSABLE_VARIABLES.a51 XDATA_VARIABLES.a51
  group Subroutines
    ./: SUBROUTINES.a51 i2c_io.lib
  group ISR_Group
    ./: ISR_T2_OVF.a51 ISR_T2_COMPARE_2.a51 ISR_T2_COMPARE_1.a51 ISR_T2_COMPARE_0.a51 ISR_ADC.a51 ISR_T2_CAPTURE_3.a51 ISR_T2_CAPTURE_2.a51 ISR_T2_CAPTURE_1.a51 ISR_T2_CAPTURE_0.a51 ISR_SERIAL.a51 ISR_TIMER1_OVF.a51 ISR_EXTERNAL1.a51 ISR_TIMER0_OVF.a51 ISR_EXTERNAL0.a51
  group Main_and_startup
    ./: main.a51 STARTUP.a51 INTERRUPT_REDIRECT_TABLE.a51 Reserved_addresses.a51
